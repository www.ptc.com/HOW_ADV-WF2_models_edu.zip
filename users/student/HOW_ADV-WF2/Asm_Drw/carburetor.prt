# Pro/ENGINEER part, saved by Pro/ENGINEER Version K-01-27 M020 (file carburetor.prt)

Parameters:
  PTC_COMMON_NAME = "carburetor.prt"