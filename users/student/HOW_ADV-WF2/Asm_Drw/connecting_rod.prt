# Pro/ENGINEER part, saved by Pro/ENGINEER Version K-01-27 M020 (file connecting_rod.prt)

Parameters:
  PTC_COMMON_NAME = "connecting_rod.prt"