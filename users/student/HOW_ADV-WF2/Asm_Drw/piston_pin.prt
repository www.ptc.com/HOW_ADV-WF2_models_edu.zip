# Pro/ENGINEER part, saved by Pro/ENGINEER Version K-01-27 M020 (file piston_pin.prt)

Parameters:
  PTC_COMMON_NAME = "piston_pin.prt"