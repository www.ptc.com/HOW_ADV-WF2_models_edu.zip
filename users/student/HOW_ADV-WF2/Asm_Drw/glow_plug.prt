# Pro/ENGINEER part, saved by Pro/ENGINEER Version K-01-27 M020 (file glow_plug.prt)

Parameters:
  PTC_COMMON_NAME = "glow_plug.prt"