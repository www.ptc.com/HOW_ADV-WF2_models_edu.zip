# Pro/ENGINEER part, saved by Pro/ENGINEER Version K-01-27 M020 (file engine_block_3.prt)

Parameters:
  PTC_COMMON_NAME = "engine_block.prt"