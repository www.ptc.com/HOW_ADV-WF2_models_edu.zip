# Pro/ENGINEER part, saved by Pro/ENGINEER Version K-01-27 M020 (file crankshaft.prt)

Parameters:
  PTC_COMMON_NAME = "crankshaft.prt"