# Pro/ENGINEER part, saved by Pro/ENGINEER Version K-01-27 M020 (file impeller_housing_2.prt)

Parameters:
  PTC_COMMON_NAME = "impeller_housing.prt"